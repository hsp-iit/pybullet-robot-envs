Commit message: new structure

File: pybullet_robot_envs/robot_data/franka_description/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=2 2 0.05; visual mesh filename=table.obj scale=0.1 0.1 0.58
